# Keil uVision project KEEN_Vent_Dev.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PZ Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KEEN_Vent_Dev +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_TM4C123_RB1,UART_BUFFERED,UART_BUFFERED1,UART_BUFFERED2
  c misc: --c99
  c include: C:\TI\TivaWare_C_Series-2.1.2.111\driverlib;C:\TI\TivaWare_C_Series-2.1.2.111\inc;C:\TI\TivaWare_C_Series-2.1.2.111
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: VentAlgorithm_Handler.c ADC_Handler.c FM3164_Memory.c LTC2607_DAC_Handler.c FM3164_WatchDog.c SFM4200_FlowSensor.c main.c uartstdio.c ModbusCommn_Handler.c Scheduler_Handler.c uartstdio1.c SystemInit_Handler.c SSI_Handler.c TechnicalAlarm_Handler.c Calib_Handler.c VolumeCtrlMode_Handler.c PressureCtrlMode_Handler.c PressureSupport.c cpap_mode.c ExhFlowSensor.c uartstdio2.c simv.c debug_mode.c PRVC.c NIV_AlgorithmHandler.c preusecheck.c patient_ckt_chk.c Diagnostics.c Medical_procedure.c
  group Libraries
    ./driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
  group CRC
    ./: CRC.c CRC16.c
  group Startup Files
    ./RTE/TM4C123GH6PZ/: system_TM4C123.c startup_rvmdk.s
software components: CMSIS:CORE 5.4.0
